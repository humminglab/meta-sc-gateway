COMPATIBLE_MACHINE:append:sc-gateway = "|sc-gateway"
