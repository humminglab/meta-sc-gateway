FILESEXTRAPATHS:prepend:sc-gateway := "${THISDIR}/files:"
